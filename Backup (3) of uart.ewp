# IAR project Backup (3) of uart.ewp, settings and files
configuration STM32_E_Version (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Firmware_LIB\include; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uart.bin
  ILINK.IlinkOutputFile: uart.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32_B_Version (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103R8 ST STM32F103R8
  General.CoreVariant: 38
  OBJCOPY.OOCOutputFile: IYANGI_PANEL.BIN
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  group Firmware_LIB/include
    ../Firmware_LIB/include/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Firmware_LIB/module
    ../Firmware_LIB/module/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group project
    ./: 24LC02.C 93C46.H 94C46.C adc.c adc.h BALANCE.C balance.h bit_define.h CAN_APP.C CAN_APP.H cortexm3_macro.s iexec.c main.c main.h stm32f10x_conf.h stm32f10x_init.c stm32f10x_init.h stm32f10x_it.c stm32f10x_it.h stm32f10x_vector.c
